# Keil uVision project YH-F429.uvprojx, settings and files
target LwIP (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: YH-F429 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx STM32_PLATFORM OSIP_MONOTHREAD MINISIZE
  c misc: --c99
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\User;..\User\usart;..\User\led;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\LwIP\include;..\LwIP\include\compat;..\LwIP\include\lwip;..\LwIP\include\netif;..\LwIP\include\lwip\apps;..\LwIP\include\lwip\priv;..\LwIP\include\lwip\prot;..\User\arch;..\User\cm_backtrace;..\User\FrameResponce;..\User\GPIO;..\User\libexosip2-5.3.0_bp\src;..\User\libexosip2-5.3.0_bp\include;..\User\libosip2-5.3.0\src\osip2;..\User\libosip2-5.3.0\src\osipparser2;..\User\libosip2-5.3.0\include;..\User\libosip2-5.3.0\include\osipparser2\headers;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group DOC
    ../Doc/: readme.txt
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group CMSIS
    ../User/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_sdram.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c
  group USER
    ../User/: main.c stm32f4xx_it.c board.c udpecho.c
    ../User/usart/: bsp_debug_usart.c
    ../User/led/: bsp_led.c
    ../User/sdram/: bsp_sdram.c
    ../User/eth/: bsp_eth.c
    ../User/FrameResponce/: Frame_Responce.c
    ../User/GPIO/: gpio.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group LwIP/api
    ../LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/core
    ../LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/netif
    ../LwIP/netif/: ethernet.c bridgeif.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group LwIP/arch
    ../User/arch/: ethernetif.c sys_arch.c
  group cm_backtrace
    ../User/cm_backtrace/: cm_backtrace.c
    ../User/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group SIP
    ../User/libosip2-5.3.0/src/osip2/: fsm_misc.c ict.c ict_fsm.c ist.c ist_fsm.c nict.c nict_fsm.c nist.c nist_fsm.c osip.c osip_dialog.c osip_event.c osip_time.c osip_transaction.c port_condv.c port_fifo.c port_sema.c port_thread.c
    ../User/libosip2-5.3.0/src/osipparser2/: osip_accept.c osip_accept_encoding.c osip_accept_language.c osip_alert_info.c osip_allow.c osip_authentication_info.c osip_authorization.c osip_body.c osip_call_id.c osip_call_info.c osip_contact.c osip_content_disposition.c osip_content_encoding.c osip_content_length.c osip_content_type.c osip_cseq.c osip_error_info.c osip_from.c osip_header.c osip_list.c osip_md5c.c osip_message.c osip_message_parse.c osip_message_to_str.c osip_mime_version.c osip_parser_cfg.c osip_port.c osip_proxy_authenticate.c osip_proxy_authentication_info.c osip_proxy_authorization.c osip_record_route.c osip_route.c osip_to.c osip_uri.c osip_via.c osip_www_authenticate.c sdp_accessor.c sdp_message.c
  group SIP_BP
    ../User/libexosip2-5.3.0_bp/src/: eXcall_api.c eXconf.c eXinsubscription_api.c eXmessage_api.c eXoptions_api.c eXosip.c eXpublish_api.c eXregister_api.c eXsubscription_api.c eXtl_dtls.c eXtl_tcp.c eXtl_tls.c eXtl_udp.c eXtransport.c eXutils.c inet_ntop.c jauth.c jcall.c jcallback.c jdialog.c jevents.c jnotify.c jpipe.c jpublish.c jreg.c jrequest.c jresponse.c jsubscribe.c milenage.c misc.c rijndael.c sdp_offans.c udp.c
    ../User/: sip_stm_dp.c
